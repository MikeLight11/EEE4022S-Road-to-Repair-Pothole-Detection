/*
 * overlay.c - draws detections onto the livestream image (RGB, in place).
 */
#include "overlay.h"

#include <ctype.h>
#include <stdlib.h>
#include <string.h>

/* 5x7 font: 7 rows per glyph, bit 4 = leftmost column. */
static const char GLYPHS[] = "0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ.:-%/# ";
static const uint8_t FONT[][7] = {
    {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E}, /* 0 */
    {0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E}, /* 1 */
    {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F}, /* 2 */
    {0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E}, /* 3 */
    {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02}, /* 4 */
    {0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E}, /* 5 */
    {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E}, /* 6 */
    {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}, /* 7 */
    {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E}, /* 8 */
    {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C}, /* 9 */
    {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}, /* A */
    {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E}, /* B */
    {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E}, /* C */
    {0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E}, /* D */
    {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F}, /* E */
    {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10}, /* F */
    {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F}, /* G */
    {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}, /* H */
    {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E}, /* I */
    {0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C}, /* J */
    {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}, /* K */
    {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F}, /* L */
    {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11}, /* M */
    {0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11}, /* N */
    {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}, /* O */
    {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10}, /* P */
    {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D}, /* Q */
    {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11}, /* R */
    {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E}, /* S */
    {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}, /* T */
    {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}, /* U */
    {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04}, /* V */
    {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A}, /* W */
    {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11}, /* X */
    {0x11, 0x11, 0x11, 0x0A, 0x04, 0x04, 0x04}, /* Y */
    {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}, /* Z */
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C}, /* . */
    {0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00}, /* : */
    {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00}, /* - */
    {0x18, 0x19, 0x02, 0x04, 0x08, 0x13, 0x03}, /* % */
    {0x00, 0x01, 0x02, 0x04, 0x08, 0x10, 0x00}, /* / */
    {0x0A, 0x0A, 0x1F, 0x0A, 0x1F, 0x0A, 0x0A}, /* # */
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}, /* space */
};

static inline void put(ov_image *im, int x, int y, const uint8_t c[3])
{
    if (x < 0 || y < 0 || x >= im->w || y >= im->h)
        return;
    uint8_t *p = im->rgb + (size_t)y * im->stride + (size_t)x * 3;
    p[0] = c[0];
    p[1] = c[1];
    p[2] = c[2];
}

static int clampi(int v, int lo, int hi)
{
    return v < lo ? lo : v > hi ? hi : v;
}

void ov_fill_rect(ov_image *im, int x0, int y0, int x1, int y1, const uint8_t color[3])
{
    x0 = clampi(x0, 0, im->w);
    x1 = clampi(x1, 0, im->w);
    y0 = clampi(y0, 0, im->h);
    y1 = clampi(y1, 0, im->h);
    for (int y = y0; y < y1; y++)
        for (int x = x0; x < x1; x++)
            put(im, x, y, color);
}

void ov_rect(ov_image *im, int x0, int y0, int x1, int y1, const uint8_t color[3], int t)
{
    ov_fill_rect(im, x0, y0, x1, y0 + t, color);
    ov_fill_rect(im, x0, y1 - t, x1, y1, color);
    ov_fill_rect(im, x0, y0, x0 + t, y1, color);
    ov_fill_rect(im, x1 - t, y0, x1, y1, color);
}

void ov_mask(ov_image *im, const ys_mask *m, int in_dx, int in_dy, const uint8_t color[3], int alpha)
{
    const uint8_t *in = m->bits;
    int w = m->w, h = m->h;
    for (int y = 0; y < h; y++) {
        int iy = m->y0 + y - in_dy;
        if (iy < 0 || iy >= im->h)
            continue;
        for (int x = 0; x < w; x++) {
            int ix = m->x0 + x - in_dx;
            if (!in[y * w + x] || ix < 0 || ix >= im->w)
                continue;
            uint8_t *p = im->rgb + (size_t)iy * im->stride + (size_t)ix * 3;
            int edge = x == 0 || y == 0 || x == w - 1 || y == h - 1 || !in[y * w + x - 1] ||
                       !in[y * w + x + 1] || !in[(y - 1) * w + x] || !in[(y + 1) * w + x];
            for (int c = 0; c < 3; c++)
                p[c] = edge ? color[c] : (uint8_t)((p[c] * (256 - alpha) + color[c] * alpha) >> 8);
        }
    }
}

static const uint8_t *glyph(char ch)
{
    const char *g = strchr(GLYPHS, toupper((unsigned char)ch));
    return FONT[g && ch ? g - GLYPHS : (int)sizeof(GLYPHS) - 2];
}

int ov_text_width(const char *s, int scale)
{
    int n = (int)strlen(s);
    return n ? (6 * n - 1) * scale : 0;
}

int ov_text(ov_image *im, int x, int y, const char *s, int scale, const uint8_t color[3])
{
    int cx = x;
    for (; *s; s++, cx += 6 * scale) {
        const uint8_t *g = glyph(*s);
        for (int r = 0; r < 7; r++)
            for (int c = 0; c < 5; c++)
                if (g[r] & (0x10 >> c))
                    ov_fill_rect(im, cx + c * scale, y + r * scale, cx + (c + 1) * scale, y + (r + 1) * scale, color);
    }
    return cx - x;
}

void ov_label(ov_image *im, int x, int y, const char *s, int scale, const uint8_t fg[3], const uint8_t bg[3])
{
    int pad = scale + 1;
    int w = ov_text_width(s, scale) + 2 * pad, h = OV_TEXT_HEIGHT(scale) + 2 * pad;
    x = clampi(x, 0, im->w - w);
    y = clampi(y, 0, im->h - h);
    ov_fill_rect(im, x, y, x + w, y + h, bg);
    ov_text(im, x + pad, y + pad, s, scale, fg);
}
